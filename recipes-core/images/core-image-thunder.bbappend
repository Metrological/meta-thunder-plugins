IMAGE_INSTALL += "\
    packagegroup-thunder-plugins \
"
