require thunder-plugins.inc

SRCREV = "f5bcbf8688c60539b8805e2778f6c82435c96fbd"
