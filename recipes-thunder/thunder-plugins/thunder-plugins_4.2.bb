require thunder-plugins.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=47b1321b4411e96bb5aeb94521850d43"

SRCREV = "92e11f1facdd9b76cb0e711592148ca13bd99a23"
