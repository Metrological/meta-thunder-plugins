require thunder-plugins.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=47b1321b4411e96bb5aeb94521850d43"

SRCREV = "ae46f4dce2da6adf359b1529779067b20e183cca"
