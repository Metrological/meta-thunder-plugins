require thunder-plugins.inc

SRCREV = "dd0f4a5f14a11c4a7c4fcbaa17f6b4605f4e80b5"
