require thunder-plugins.inc

SRCREV = "fa346fd703967a3b0b337681169d412be5b34135"
