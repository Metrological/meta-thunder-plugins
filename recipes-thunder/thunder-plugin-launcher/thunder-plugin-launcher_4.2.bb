require thunder-plugin-launcher.inc

SRCREV = "139f79fd9149841dc6edcf561d01df0010b47db7"
