require thunder-plugin-launcher.inc

SRCREV = "6cd5c8f3bcef248d290f58c18a55cf54fc2d1b46"
