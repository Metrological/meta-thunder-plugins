require thunder-plugin-launcher.inc

SRCREV = "5aa8feaf9b44016e363b9a936914cf86e3bf0ac9"
