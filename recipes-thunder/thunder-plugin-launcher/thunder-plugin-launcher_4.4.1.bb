require thunder-plugin-launcher.inc

SRCREV = "5d9a5c45bba36e503aff93db08ca98deec7591e9"
