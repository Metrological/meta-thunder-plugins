require thunder-plugins-rdk.inc

SRCREV = "68cb55f538046245ca9046e8b8c7bf31e07fc0ce"
