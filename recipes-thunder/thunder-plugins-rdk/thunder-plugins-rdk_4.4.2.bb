require thunder-plugins-rdk.inc

SRCREV = "60adf70a383de007014c6db275466979df9df28d"
