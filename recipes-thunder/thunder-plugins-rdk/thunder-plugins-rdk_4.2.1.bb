require thunder-plugins-rdk.inc

SRCREV = "7fb0b598ab6bd87b49235b99770a3162bb3691e1"
