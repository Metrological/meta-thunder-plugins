require thunder-plugins-rdk.inc

SRCREV = "5a19df4730fc9f98bfcea273520d2074baf49ed4"
