require thunder-plugins-rdk.inc

SRCREV = "f970a07295e4f24039583c9d6eae5cd83f00c733"
