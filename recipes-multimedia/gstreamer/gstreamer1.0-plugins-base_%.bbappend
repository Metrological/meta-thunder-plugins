PACKAGECONFIG[gl] = "-Dgl=enabled ,,"
PACKAGECONFIG:append:dunfell = " gl"
PACKAGECONFIG:append = " opus"

